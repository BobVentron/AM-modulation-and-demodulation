options:
  parameters:
    generate_options: qt_gui
    id: modulateurAM
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: '15000'
    offset: '0'
    phase: '0'
    samp_rate: '48000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: audio_sink_0_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: audio_sink_0_0_1
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '4000'
    low_cutoff_freq: '20'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '2'
    high_cutoff_freq: '8000'
    low_cutoff_freq: '50'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_1_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '2'
    high_cutoff_freq: '4000'
    low_cutoff_freq: '50'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_2
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '15300'
    low_cutoff_freq: '14700'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '2000'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: '48000'
    type: float
  states: {}
- name: blocks_throttle2_0_1
  id: blocks_throttle2
  parameters:
    samples_per_second: '48000'
    type: float
  states: {}
- name: blocks_throttle2_0_1_0
  id: blocks_throttle2
  parameters:
    samples_per_second: '48000'
    type: float
  states: {state: disabled}
- name: blocks_throttle2_0_1_1
  id: blocks_throttle2
  parameters:
    samples_per_second: '48000'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\basti\OneDrive\Bureau\vtt evasion genilac\musique libre de droit\beauteous-upbeat-electronic-162757.mp3
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '960000'
    fc: '0'
    fftsize: '2048'
    name: '"apres mod"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '960000'
    fc: '0'
    fftsize: '2048'
    name: '"demod apres mod"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: '960000'
    fc: '0'
    fftsize: '2048'
    name: '"avant mod"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"test"'
    size: '1024'
    srate: '960000'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: demod
    size: '1024'
    srate: '960000'
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [band_pass_filter_1, '0', blocks_multiply_const_vxx_2, '0']
- [band_pass_filter_1_0, '0', blocks_throttle2_0_1_1, '0']
- [band_pass_filter_2, '0', blocks_multiply_xx_1, '1']
- [blocks_add_xx_0, '0', blocks_throttle2_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_const_vxx_1, '0', band_pass_filter_1_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_multiply_xx_1, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_1, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_throttle2_0_0, '0', band_pass_filter_0, '0']
- [blocks_throttle2_0_1, '0', audio_sink_0_0, '0']
- [blocks_throttle2_0_1, '0', band_pass_filter_1, '0']
- [blocks_throttle2_0_1, '0', band_pass_filter_2, '0']
- [blocks_throttle2_0_1_0, '0', audio_sink_0_0_0, '0']
- [blocks_throttle2_0_1_1, '0', audio_sink_0_0_1, '0']
- [blocks_throttle2_0_1_1, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_throttle2_0_1_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0_1_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_freq_sink_x_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
